Commit message: Updated

File: src/simulation/urdf/simulation.urdf (robot description, URDF)
Before this commit: robot simulation, 8 links, 5 joints
Links:
- removed link base_link
- removed link fcu
